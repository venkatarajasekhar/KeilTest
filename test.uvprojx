# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ADuCM360 Analog Devices
  pack: AnalogDevices.ADuCM36x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\KeilTest
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c ADuCM360_Regs.h ADuCM360_Regs.c GPIOTEST.c Polling_UART_Ex1.c JongSuLib.c JongSuLib.h
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
